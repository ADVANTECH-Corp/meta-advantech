FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://ota_rmm_agent.patch"	
