DESCRIPTION = "TI arago base image with Advantech EdgeSense feature"

require wise-paas.inc
