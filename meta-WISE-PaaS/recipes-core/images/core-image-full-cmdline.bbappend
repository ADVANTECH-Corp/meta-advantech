DESCRIPTION = "Yocto core image with Advantech EdgeSense feature"

require wise-paas.inc
