DESCRIPTION = "TI arago image with Advantech EdgeSense feature"

require wise-paas.inc
