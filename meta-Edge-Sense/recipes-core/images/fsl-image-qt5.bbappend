DESCRIPTION = "FSL QT5 image with Advantech EdgeSense feature"

require edge-image.inc
