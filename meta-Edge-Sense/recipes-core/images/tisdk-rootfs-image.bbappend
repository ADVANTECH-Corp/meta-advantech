DESCRIPTION = "TI arago image with Advantech EdgeSense feature"

IMAGE_INSTALL_append = " nodejs nodejs-npm node-red zsh "
