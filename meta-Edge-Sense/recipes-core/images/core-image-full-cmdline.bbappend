DESCRIPTION = "Yocto core image with Advantech EdgeSense feature"

require edge-image.inc
