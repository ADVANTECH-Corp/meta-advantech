DESCRIPTION = "Quark fully functional image with Advantech EdgeSense feature"

require edge-image.inc
