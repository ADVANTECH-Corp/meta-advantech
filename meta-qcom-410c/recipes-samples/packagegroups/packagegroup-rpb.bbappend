# Remove Network Manager & Docker
RDEPENDS_packagegroup-rpb_remove = " networkmanager networkmanager-nmtui docker "
