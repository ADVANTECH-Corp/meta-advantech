# Remove Chromium
RDEPENDS_packagegroup-rpb-x11_remove = " chromium "
