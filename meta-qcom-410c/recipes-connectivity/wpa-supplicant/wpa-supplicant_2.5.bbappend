# [Workaround] Disable wpa_supplicant.service
SYSTEMD_SERVICE_${PN} = ""

