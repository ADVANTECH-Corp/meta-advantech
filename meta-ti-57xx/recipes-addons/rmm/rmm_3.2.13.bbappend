# Copyright (C) 2015 2016 Advantech

DEPENDS = "avahi openssl curl libxml2 jpeg zlib \
           sqlite3 mosquitto \
           libmodbus"


