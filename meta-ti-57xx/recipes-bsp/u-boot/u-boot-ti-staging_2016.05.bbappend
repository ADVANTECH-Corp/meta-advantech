BRANCH = "ti-u-boot-2016.05"
SRC_URI = "git://github.com/ADVANTECH-Corp/uboot-ti.git;protocol=git;branch=${BRANCH}"
SRCREV = "am57xxLBV1001"
