RDEPENDS_${PN} += "\
   curl curl-dev \
   mosquitto mosquitto-dev \
   c-ares \
   "



