# Fix the issue 3.4.x branch has been deleted
SRC_URI = "git://github.com/google/protobuf.git;"
