RDEPENDS_${PN} = "perl"
