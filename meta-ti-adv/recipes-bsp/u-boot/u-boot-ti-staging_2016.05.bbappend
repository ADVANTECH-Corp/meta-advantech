BRANCH = "ti-u-boot-2016.05"
SRC_URI = "git://github.com/ADVANTECH-Corp/uboot-ti.git;protocol=git;branch=${BRANCH}"
SRCREV = "6cbb547337c4b7c24d152d4dd419d5251b437ca3"
UBOOT_LOCALVERSION = "-RSB4220A1LIV1040"
