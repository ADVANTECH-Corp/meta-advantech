RDEPENDS_${PN} = "\
    ${UTILS} \
    ${DEVTOOLS} \
    ${EXTRA_LIBS} \
"

