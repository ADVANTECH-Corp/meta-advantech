RDEPENDS_${PN}_remove = " ${UTILS_UBOOT_FW} \
"

