FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Add-postinit-to-skip-ALSA-default-configuration.patch"
