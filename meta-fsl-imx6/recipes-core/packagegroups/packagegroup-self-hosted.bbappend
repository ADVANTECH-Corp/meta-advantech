RDEPENDS_packagegroup-self-hosted-host-tools_remove = "\
    connman \
    connman-plugin-ethernet \
    "
