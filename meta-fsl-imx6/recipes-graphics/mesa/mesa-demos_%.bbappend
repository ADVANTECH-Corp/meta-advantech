# Fix build error
SRC_URI_remove = "file://0012-Fix-gles-configurability.patch"
