# Advantech: skip init script for autohdmi

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

INITSCRIPT_NAME = ""
INITSCRIPT_PARAMS = ""
