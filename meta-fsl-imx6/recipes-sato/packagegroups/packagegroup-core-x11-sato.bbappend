NETWORK_MANAGER = ""
