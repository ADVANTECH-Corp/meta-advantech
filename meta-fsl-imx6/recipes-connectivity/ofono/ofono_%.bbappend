# Advantech: skip init script for ofono

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

INITSCRIPT_NAME = ""
INITSCRIPT_PARAMS = ""
